# SPDX-FileCopyrightText: 2012 Andrei Gherzan <andrei@gherzan.ro>
# SPDX-License-Identifier: MIT

EXTRA_OECONF:append:raspberrypi = " --disable-asm"
EXTRA_OECONF:append:raspberrypi0-wifi = " --disable-asm"

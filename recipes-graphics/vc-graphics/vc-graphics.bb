# SPDX-FileCopyrightText: 2012 Andrei Gherzan <andrei@gherzan.ro>
# SPDX-License-Identifier: MIT


CONFLICTS = "vc-graphics-hardfp"

VCDIR = "opt/vc"
require vc-graphics.inc

PR = "${INCPR}.0"

# SPDX-FileCopyrightText: 2012  meta-raspberrypi contributors
#
# SPDX-License-Identifier: MIT


FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
